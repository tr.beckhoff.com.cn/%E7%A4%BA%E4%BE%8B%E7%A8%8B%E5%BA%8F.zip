PROGRAM MAIN
VAR
	
	
END_VAR

END_PROGRAM
