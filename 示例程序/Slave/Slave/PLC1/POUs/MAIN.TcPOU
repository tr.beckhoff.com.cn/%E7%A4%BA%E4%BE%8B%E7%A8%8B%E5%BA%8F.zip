PROGRAM MAIN
VAR
	b1 AT %I*: BOOL;
	b2 AT %i*: BOOL;
	q1 AT %q*: BOOL;
	V: INT;
END_VAR

IF b1 THEN
	q1 :=TRUE;
END_IF

IF b2 THEN
	q1 :=FALSE;
END_IF

V:=V+1;

END_PROGRAM
